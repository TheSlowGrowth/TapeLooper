File: hardware/mainboard/Channel_LEDs.kicad_sch (KiCad schematic)
At the start: 54 parts

Commit message: hardware: resave files with KiCad v7.0.4
Parts:
- gave numbers to parts that had none: 54
